* A simple RC circuit
V1 1 0 DC 5
R1 1 2 1k
C1 2 0 1u IC=0
.tran 0.1m 5m
.end
